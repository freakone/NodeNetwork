# Keil uVision project rfm73-stmnode.uvprojx, settings and files
target STM32F303 Flash (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: main +hex
  c flags: Optim=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Files
    ./: main.c rfm73.c rfm73.h
  group Documentation
    ./: Abstract.txt
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS_RTX/LIB/ARM/: RTX_CM3.lib
  group ::Device
    RTE/Device/STM32F303VC/: startup_stm32f30x.s system_stm32f30x.c
target STM32F303 RAM (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F30X VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.73.0, Device:Startup 1.0.0
